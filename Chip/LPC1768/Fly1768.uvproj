# Keil uVision project Fly1768.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Fly1768 +hex
  c flags: Optim=1
  c include: .\Drivers\include;.\Interface\inc;..\..\Common\Inc;..\..\uCOS-II\Ports;..\..\uCFS\Inc;..\..\LwIP\src\include\arch;..\..\LwIP\src\include\lwip;..\..\LwIP\src\include\netif;..\..\LwIP\src\include;..\..\LwIP\src\include\ipv4;..\..\LwIP\src\include\ipv6
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Fly1768.sct
  group Startup
    ./: startup_LPC17xx.s
  group CM3
    ./Core/CoreSupport/: core_cm3.c
    ./Core/DeviceSupport/: system_LPC17xx.c
  group Drivers
    ./Drivers/source/: lpc17xx_adc.c lpc17xx_clkpwr.c lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_spi.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c lpc17xx_can.c lpc17xx_ssp.c lpc17xx_emac.c
  group uCOS_II Port
    ../../uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm
  group uCOS_II Source
    ../../uCOS-II/Source/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.C
  group uCFS
    ../../uCFS/Source/: api_dir.c api_in.c api_misc.c api_out.c clibmisc.c fat_data.c fat_dir.c fat_in.c fat_ioct.c fat_misc.c fat_open.c fat_out.c fs_dev.c fs_info.c fs_x_ucos_ii.c lb_misc.c mmc_X_hw.c
  group LwIP
    ../../LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../LwIP/src/arch/: sys_arch.c
    ../../LwIP/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../../LwIP/src/netif/: etharp.c ethernetif.c slipif.c
  group Interface
    ./Interface/src/: IAP.c interface.c
  group CommFunc
    ../../Common/Src/: main.c ipcExchange.c demoDebugTask.c flyFileTask.c flySystemTask.c flyEthernetTask.c
